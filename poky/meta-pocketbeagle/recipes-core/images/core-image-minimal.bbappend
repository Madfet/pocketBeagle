IMAGE_INSTALL:append = " dropbear"

